# CATIA V5 part "CI1816150.CATPart"
Saved by CATIA V5R20 SP0, build 10-29-2009
Part number: CI1816150
Bounding box of the stored display mesh (mm): x -15 to 15, y -11.308 to 174, z -19.756 to 16.81
Stored file links:
  C:\Users\Raffaele\Desktop\3D X SITO CF\BOLEX\19-INCLINED ASSEMBLY REF_CI\CI1816150.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Set1
  DatumSurface1 to DatumSurface16 "MANIFOLD_SOLID_BREP #385"
  DatumSurface17 to DatumSurface39 "MANIFOLD_SOLID_BREP #1110"
Body1 (main body)