# CATIA V5 part "CI1220100.CATPart"
Saved by CATIA V5R20 SP0, build 10-29-2009
Part number: CI1220100
Bounding box of the stored display mesh (mm): x -19 to 19, y -15.368 to 130, z -21.949 to 22.289
Stored file links:
  C:\Users\Raffaele\Desktop\3D X SITO CF\BOLEX\19-INCLINED ASSEMBLY REF_CI\CI1220100.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Set1
  DatumSurface1 to DatumSurface16 "MANIFOLD_SOLID_BREP #385"
  DatumSurface17 to DatumSurface39 "MANIFOLD_SOLID_BREP #1114"
Body1 (main body)