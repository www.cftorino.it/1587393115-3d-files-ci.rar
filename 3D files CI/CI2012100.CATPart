# CATIA V5 part "CI2012100.CATPart"
Saved by CATIA V5R20 SP0, build 10-29-2009
Part number: CI2012100
Bounding box of the stored display mesh (mm): x -12 to 12, y -9.679 to 118, z -16.11 to 13.284
Stored file links:
  C:\Users\Raffaele\Desktop\3D X SITO CF\BOLEX\19-INCLINED ASSEMBLY REF_CI\CI2012100.CATPart

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
Set1
  DatumSurface1 to DatumSurface16 "MANIFOLD_SOLID_BREP #380"
  DatumSurface17 to DatumSurface39 "MANIFOLD_SOLID_BREP #1099"
Body1 (main body)